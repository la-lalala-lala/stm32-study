# Keil uVision project CH395.uvprojx, settings and files
target CH395 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103C8 +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SRC\CORE;..\SRC\DEBUG;..\SRC\FWLIB\inc;..\PUB;.\MAIL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../SRC/CORE/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group FWLIB
    ../SRC/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DEBUG
    ../SRC/DEBUG/: debug.c
  group APP
    ./: main.c
  group PUB
    ../PUB/: CH395CMD.c CH395SPI_HW.c
  group MAIL
    ./MAIL/: CH395.C ch395MAIL.C CH395MAILCMD.C
    ../PUB/: CH395UART_HW.c CH395PARA_HW.c
